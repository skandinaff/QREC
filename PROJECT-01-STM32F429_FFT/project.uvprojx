# Keil uVision project project.uvprojx, settings and files
target STM32F429-Discovery (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: .\User;.\TM;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;.\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group STD_Periph_Drivers
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group DSP
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_bitreversal.c
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_min_f32.c
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_adc.c tm_stm32f4_adc.h tm_stm32f4_dac_signal.c tm_stm32f4_dac_signal.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_ili9341_ltdc.c tm_stm32f4_ili9341_ltdc.h tm_stm32f4_sdram.c tm_stm32f4_sdram.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_timer_properties.c tm_stm32f4_timer_properties.h
    ./TM/: tm_stm32f4_button.c tm_stm32f4_button.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h
  group User
    ./User/: defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c main.c usart.c usart.h init_periph_irqs.c init_periph_irqs.h detect_whistle.c detect_whistle.h cup_detection.c cup_detection.h pulse_reading.c pulse_reading.h movement_detection.c movement_detection.h leds.c leds.h quest.c quest.h LPH8731-3C.c LPH8731-3C.h
